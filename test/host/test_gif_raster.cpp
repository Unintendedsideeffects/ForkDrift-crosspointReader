#include <cstddef>
#include <cstdint>
#include <vector>

#include "DitherUtils.h"
#include "GifRaster.h"
#include "ImageMagic.h"
#include "doctest/doctest.h"

#if ENABLE_EPUB_GIF

namespace {

struct BitWriter {
  std::vector<uint8_t> bytes;
  uint32_t acc = 0;
  int nbits = 0;

  void write(uint32_t code, int width) {
    acc |= code << nbits;
    nbits += width;
    while (nbits >= 8) {
      bytes.push_back(static_cast<uint8_t>(acc & 0xFF));
      acc >>= 8;
      nbits -= 8;
    }
  }

  void flush() {
    if (nbits > 0) {
      bytes.push_back(static_cast<uint8_t>(acc & 0xFF));
    }
    acc = 0;
    nbits = 0;
  }
};

struct DictEntry {
  int prefix;
  int suffix;
  int code;
};

int dictLookup(const std::vector<DictEntry>& table, int prefix, int suffix) {
  for (const DictEntry& entry : table) {
    if (entry.prefix == prefix && entry.suffix == suffix) {
      return entry.code;
    }
  }
  return -1;
}

std::vector<uint8_t> lzwCompress(const std::vector<uint8_t>& pixels, int minCodeSize) {
  const int clear = 1 << minCodeSize;
  const int eoi = clear + 1;
  int codeSize = minCodeSize + 1;
  int next = eoi + 1;
  std::vector<DictEntry> table;
  BitWriter bits;
  bits.write(static_cast<uint32_t>(clear), codeSize);
  int cur = pixels[0];
  for (size_t i = 1; i < pixels.size(); i++) {
    const int pix = pixels[i];
    const int found = dictLookup(table, cur, pix);
    if (found >= 0) {
      cur = found;
      continue;
    }
    bits.write(static_cast<uint32_t>(cur), codeSize);
    if (next < gifraster::kLzwCodeCount) {
      table.push_back(DictEntry{cur, pix, next});
      next++;
      // The decoder adds each entry one code later than the encoder (the first code after a clear
      // adds nothing), so a GIF encoder widens one code after `next` reaches 1 << codeSize.
      if (next > (1 << codeSize) && codeSize < 12) {
        codeSize++;
      }
    }
    cur = pix;
  }
  bits.write(static_cast<uint32_t>(cur), codeSize);
  bits.write(static_cast<uint32_t>(eoi), codeSize);
  bits.flush();
  return bits.bytes;
}

void appendSubBlocks(std::vector<uint8_t>& out, const std::vector<uint8_t>& data) {
  size_t i = 0;
  while (i < data.size()) {
    const size_t n = data.size() - i > 255 ? 255 : data.size() - i;
    out.push_back(static_cast<uint8_t>(n));
    out.insert(out.end(), data.begin() + static_cast<std::ptrdiff_t>(i),
               data.begin() + static_cast<std::ptrdiff_t>(i + n));
    i += n;
  }
  out.push_back(0);
}

void appendU16(std::vector<uint8_t>& out, uint16_t value) {
  out.push_back(static_cast<uint8_t>(value & 0xFF));
  out.push_back(static_cast<uint8_t>(value >> 8));
}

int tableBitsForCount(int count) {
  int bits = 0;
  while ((2 << bits) < count) {
    bits++;
  }
  return bits;
}

std::vector<uint8_t> interlaceOrder(const std::vector<uint8_t>& display, int width, int height) {
  static constexpr int kStart[4] = {0, 4, 2, 1};
  static constexpr int kStep[4] = {8, 8, 4, 2};
  std::vector<uint8_t> ordered;
  ordered.reserve(display.size());
  for (int pass = 0; pass < 4; pass++) {
    for (int y = kStart[pass]; y < height; y += kStep[pass]) {
      const int row = y * width;
      ordered.insert(ordered.end(), display.begin() + row, display.begin() + row + width);
    }
  }
  return ordered;
}

struct GifSpec {
  int width = 1;
  int height = 1;
  bool gif89 = false;
  bool interlaced = false;
  int transparent = -1;
  std::vector<uint8_t> gct;
  std::vector<uint8_t> lct;
  std::vector<uint8_t> pixels;
};

std::vector<uint8_t> buildGif(const GifSpec& spec) {
  const int gctCount = static_cast<int>(spec.gct.size() / 3);
  const int lctCount = static_cast<int>(spec.lct.size() / 3);
  const int gctBits = gctCount > 0 ? tableBitsForCount(gctCount) : 0;
  const int lctBits = lctCount > 0 ? tableBitsForCount(lctCount) : 0;
  const int gctSlots = gctCount > 0 ? (2 << gctBits) : 0;
  const int lctSlots = lctCount > 0 ? (2 << lctBits) : 0;
  int minCodeSize = 2;
  if (lctCount > 0) {
    minCodeSize = lctBits + 1;
  } else if (gctCount > 0) {
    minCodeSize = gctBits + 1;
  }
  if (minCodeSize < 2) {
    minCodeSize = 2;
  }

  std::vector<uint8_t> raster = spec.pixels;
  if (spec.interlaced) {
    raster = interlaceOrder(spec.pixels, spec.width, spec.height);
  }
  const std::vector<uint8_t> compressed = lzwCompress(raster, minCodeSize);

  std::vector<uint8_t> out;
  out.insert(out.end(), {'G', 'I', 'F', '8', static_cast<uint8_t>(spec.gif89 ? '9' : '7'), 'a'});
  appendU16(out, static_cast<uint16_t>(spec.width));
  appendU16(out, static_cast<uint16_t>(spec.height));
  uint8_t packedLsd = 0;
  if (gctCount > 0) {
    packedLsd = static_cast<uint8_t>(0x80 | gctBits);
  }
  out.push_back(packedLsd);
  out.push_back(0);
  out.push_back(0);
  if (gctCount > 0) {
    out.insert(out.end(), spec.gct.begin(), spec.gct.end());
    out.resize(out.size() + static_cast<size_t>((gctSlots - gctCount) * 3), 0);
  }
  if (spec.transparent >= 0) {
    out.push_back(0x21);
    out.push_back(0xF9);
    out.push_back(0x04);
    out.push_back(0x01);
    out.push_back(0);
    out.push_back(0);
    out.push_back(static_cast<uint8_t>(spec.transparent));
    out.push_back(0);
  }
  out.push_back(0x2C);
  appendU16(out, 0);
  appendU16(out, 0);
  appendU16(out, static_cast<uint16_t>(spec.width));
  appendU16(out, static_cast<uint16_t>(spec.height));
  uint8_t packedImg = 0;
  if (spec.interlaced) {
    packedImg |= 0x40;
  }
  if (lctCount > 0) {
    packedImg |= static_cast<uint8_t>(0x80 | lctBits);
  }
  out.push_back(packedImg);
  if (lctCount > 0) {
    out.insert(out.end(), spec.lct.begin(), spec.lct.end());
    out.resize(out.size() + static_cast<size_t>((lctSlots - lctCount) * 3), 0);
  }
  out.push_back(static_cast<uint8_t>(minCodeSize));
  appendSubBlocks(out, compressed);
  out.push_back(0x3B);
  return out;
}

struct Catcher {
  int width = 0;
  int height = 0;
  bool interlaced = false;
  bool beginCalled = false;
  std::vector<std::vector<uint8_t>> rows;
};

bool onBegin(void* ctx, const gifraster::DecodeInfo& info) {
  auto* catcher = static_cast<Catcher*>(ctx);
  catcher->width = info.width;
  catcher->height = info.height;
  catcher->interlaced = info.interlaced;
  catcher->beginCalled = true;
  catcher->rows.assign(static_cast<size_t>(info.height), std::vector<uint8_t>(static_cast<size_t>(info.width), 0xEE));
  return true;
}

bool onRow(void* ctx, int y, const uint8_t* gray, int width) {
  auto* catcher = static_cast<Catcher*>(ctx);
  if (y < 0 || y >= catcher->height || width != catcher->width) {
    return false;
  }
  catcher->rows[static_cast<size_t>(y)].assign(gray, gray + width);
  return true;
}

gifraster::Status decodeTo(const std::vector<uint8_t>& gif, Catcher& catcher) {
  return gifraster::decodeMemory(gif.data(), gif.size(), onBegin, onRow, &catcher);
}

}  // namespace

TEST_CASE("GIF peak heap stays under 20 KB") {
  CHECK(gifraster::kPeakHeapBytes <= 20 * 1024);
  CHECK(gifraster::kPeakHeapBytes == 19456);
}

TEST_CASE("factory sniff classifies GIF magic without an extension") {
  const uint8_t gif87[] = {'G', 'I', 'F', '8', '7', 'a', 1, 0};
  const uint8_t gif89[] = {'G', 'I', 'F', '8', '9', 'a', 1, 0};
  const uint8_t jpeg[] = {0xFF, 0xD8, 0xFF, 0xE0};
  const uint8_t notGif[] = {'G', 'A', 'R', 'B', 'A', 'G', 'E'};
  CHECK(sniffImageMagic(gif87, 6) == SniffedFormat::Gif);
  CHECK(sniffImageMagic(gif89, 8) == SniffedFormat::Gif);
  CHECK(sniffImageMagic(jpeg, 4) == SniffedFormat::Jpeg);
  CHECK(sniffImageMagic(notGif, 7) == SniffedFormat::Unknown);
  CHECK(sniffImageMagic(gif87, 5) == SniffedFormat::Unknown);
}

TEST_CASE("GIF decoder reads a 1x1 two-colour GIF87a") {
  GifSpec spec;
  spec.width = 1;
  spec.height = 1;
  spec.gct = {0, 0, 0, 255, 255, 255};
  spec.pixels = {0};
  Catcher catcher;
  REQUIRE(decodeTo(buildGif(spec), catcher) == gifraster::Status::Ok);
  CHECK(catcher.beginCalled);
  CHECK(catcher.width == 1);
  CHECK(catcher.height == 1);
  CHECK(catcher.rows[0][0] == 0);
}

TEST_CASE("GIF decoder expands a dictionary code and KwKwK") {
  {
    GifSpec spec;
    spec.width = 1;
    spec.height = 4;
    spec.gct = {0, 0, 0, 255, 255, 255};
    spec.pixels = {0, 1, 0, 1};
    Catcher catcher;
    REQUIRE(decodeTo(buildGif(spec), catcher) == gifraster::Status::Ok);
    CHECK(catcher.rows[0][0] == 0);
    CHECK(catcher.rows[1][0] == 255);
    CHECK(catcher.rows[2][0] == 0);
    CHECK(catcher.rows[3][0] == 255);
  }
  {
    GifSpec spec;
    spec.width = 1;
    spec.height = 3;
    spec.gct = {0, 0, 0, 255, 255, 255};
    spec.pixels = {0, 0, 0};
    Catcher catcher;
    REQUIRE(decodeTo(buildGif(spec), catcher) == gifraster::Status::Ok);
    CHECK(catcher.rows[0][0] == 0);
    CHECK(catcher.rows[1][0] == 0);
    CHECK(catcher.rows[2][0] == 0);
  }
}

TEST_CASE("GIF decoder expands a 2x2 two-colour GIF87a through LZW") {
  GifSpec spec;
  spec.width = 2;
  spec.height = 2;
  spec.gct = {0, 0, 0, 255, 255, 255};
  spec.pixels = {0, 1, 1, 0};
  Catcher catcher;
  REQUIRE(decodeTo(buildGif(spec), catcher) == gifraster::Status::Ok);
  CHECK(catcher.rows[0][0] == 0);
  CHECK(catcher.rows[0][1] == 255);
  CHECK(catcher.rows[1][0] == 255);
  CHECK(catcher.rows[1][1] == 0);
  CHECK(applyBayerDither4Level(catcher.rows[0][0], 0, 0) == 0);
  CHECK(applyBayerDither4Level(catcher.rows[0][1], 1, 0) == 3);
  CHECK(applyBayerDither4Level(catcher.rows[1][0], 0, 1) == 3);
  CHECK(applyBayerDither4Level(catcher.rows[1][1], 1, 1) == 0);
}

TEST_CASE("GIF decoder deinterlaces pass order into display rows") {
  GifSpec spec;
  spec.width = 1;
  spec.height = 8;
  spec.interlaced = true;
  spec.gct = {
      0, 0, 0, 32, 32, 32, 64, 64, 64, 96, 96, 96, 128, 128, 128, 160, 160, 160, 192, 192, 192, 224, 224, 224,
  };
  spec.pixels = {0, 1, 2, 3, 4, 5, 6, 7};
  Catcher catcher;
  REQUIRE(decodeTo(buildGif(spec), catcher) == gifraster::Status::Ok);
  CHECK(catcher.interlaced);
  for (int y = 0; y < 8; y++) {
    const uint8_t expected = static_cast<uint8_t>((spec.gct[static_cast<size_t>(y) * 3] * 77 +
                                                   spec.gct[static_cast<size_t>(y) * 3 + 1] * 150 +
                                                   spec.gct[static_cast<size_t>(y) * 3 + 2] * 29) >>
                                                  8);
    CHECK(catcher.rows[static_cast<size_t>(y)][0] == expected);
  }
}

TEST_CASE("GIF decoder fails closed on a truncated file") {
  GifSpec spec;
  spec.width = 2;
  spec.height = 2;
  spec.gct = {0, 0, 0, 255, 255, 255};
  spec.pixels = {0, 1, 1, 0};
  std::vector<uint8_t> gif = buildGif(spec);
  REQUIRE(gif.size() > 8);
  gif.resize(gif.size() - 8);
  Catcher catcher;
  CHECK(decodeTo(gif, catcher) == gifraster::Status::Truncated);
}

TEST_CASE("GIF decoder renders the transparency index as white") {
  GifSpec spec;
  spec.width = 1;
  spec.height = 1;
  spec.gif89 = true;
  spec.transparent = 0;
  spec.gct = {0, 0, 0, 255, 255, 255};
  spec.pixels = {0};
  Catcher catcher;
  REQUIRE(decodeTo(buildGif(spec), catcher) == gifraster::Status::Ok);
  CHECK(catcher.rows[0][0] == 255);
}

TEST_CASE("GIF decoder uses a local colour table over the global one") {
  GifSpec spec;
  spec.width = 1;
  spec.height = 1;
  spec.gct = {0, 0, 0, 0, 0, 0};
  spec.lct = {255, 255, 255, 0, 0, 0};
  spec.pixels = {0};
  Catcher catcher;
  REQUIRE(decodeTo(buildGif(spec), catcher) == gifraster::Status::Ok);
  CHECK(catcher.rows[0][0] == 255);
}

TEST_CASE("GIF decoder rejects zero and oversized frames") {
  {
    GifSpec spec;
    spec.width = 0;
    spec.height = 1;
    spec.gct = {0, 0, 0, 255, 255, 255};
    spec.pixels = {0};
    Catcher catcher;
    CHECK(decodeTo(buildGif(spec), catcher) == gifraster::Status::TooLarge);
  }
  {
    GifSpec spec;
    spec.width = gifraster::kMaxLineWidth + 1;
    spec.height = 1;
    spec.gct = {0, 0, 0, 255, 255, 255};
    spec.pixels.assign(static_cast<size_t>(spec.width), 0);
    Catcher catcher;
    CHECK(decodeTo(buildGif(spec), catcher) == gifraster::Status::TooLarge);
  }
}

// Encoded by Pillow (an independent GIF encoder): 37x29, interlaced, 200 palette entries, so the LZW
// code width grows past 8 bits. Guards decoder and in-file fixture encoder against sharing one bug.
static uint32_t gifCrc32(const std::vector<uint8_t>& data) {
  uint32_t crc = 0xFFFFFFFFu;
  for (const uint8_t byte : data) {
    crc ^= byte;
    for (int bit = 0; bit < 8; bit++) crc = (crc >> 1) ^ (0xEDB88320u & (0u - (crc & 1u)));
  }
  return ~crc;
}

constexpr uint8_t kPillowInterlaced37x29[] = {
    0x47, 0x49, 0x46, 0x38, 0x37, 0x61, 0x25, 0x00, 0x1D, 0x00, 0x87, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x07, 0x0D,
    0x02, 0x0E, 0x1A, 0x03, 0x15, 0x27, 0x04, 0x1C, 0x34, 0x05, 0x23, 0x41, 0x06, 0x2A, 0x4E, 0x07, 0x31, 0x5B, 0x08,
    0x38, 0x68, 0x09, 0x3F, 0x75, 0x0A, 0x46, 0x82, 0x0B, 0x4D, 0x8F, 0x0C, 0x54, 0x9C, 0x0D, 0x5B, 0xA9, 0x0E, 0x62,
    0xB6, 0x0F, 0x69, 0xC3, 0x10, 0x70, 0xD0, 0x11, 0x77, 0xDD, 0x12, 0x7E, 0xEA, 0x13, 0x85, 0xF7, 0x14, 0x8C, 0x04,
    0x15, 0x93, 0x11, 0x16, 0x9A, 0x1E, 0x17, 0xA1, 0x2B, 0x18, 0xA8, 0x38, 0x19, 0xAF, 0x45, 0x1A, 0xB6, 0x52, 0x1B,
    0xBD, 0x5F, 0x1C, 0xC4, 0x6C, 0x1D, 0xCB, 0x79, 0x1E, 0xD2, 0x86, 0x1F, 0xD9, 0x93, 0x20, 0xE0, 0xA0, 0x21, 0xE7,
    0xAD, 0x22, 0xEE, 0xBA, 0x23, 0xF5, 0xC7, 0x24, 0xFC, 0xD4, 0x25, 0x03, 0xE1, 0x26, 0x0A, 0xEE, 0x27, 0x11, 0xFB,
    0x28, 0x18, 0x08, 0x29, 0x1F, 0x15, 0x2A, 0x26, 0x22, 0x2B, 0x2D, 0x2F, 0x2C, 0x34, 0x3C, 0x2D, 0x3B, 0x49, 0x2E,
    0x42, 0x56, 0x2F, 0x49, 0x63, 0x30, 0x50, 0x70, 0x31, 0x57, 0x7D, 0x32, 0x5E, 0x8A, 0x33, 0x65, 0x97, 0x34, 0x6C,
    0xA4, 0x35, 0x73, 0xB1, 0x36, 0x7A, 0xBE, 0x37, 0x81, 0xCB, 0x38, 0x88, 0xD8, 0x39, 0x8F, 0xE5, 0x3A, 0x96, 0xF2,
    0x3B, 0x9D, 0xFF, 0x3C, 0xA4, 0x0C, 0x3D, 0xAB, 0x19, 0x3E, 0xB2, 0x26, 0x3F, 0xB9, 0x33, 0x40, 0xC0, 0x40, 0x41,
    0xC7, 0x4D, 0x42, 0xCE, 0x5A, 0x43, 0xD5, 0x67, 0x44, 0xDC, 0x74, 0x45, 0xE3, 0x81, 0x46, 0xEA, 0x8E, 0x47, 0xF1,
    0x9B, 0x48, 0xF8, 0xA8, 0x49, 0xFF, 0xB5, 0x4A, 0x06, 0xC2, 0x4B, 0x0D, 0xCF, 0x4C, 0x14, 0xDC, 0x4D, 0x1B, 0xE9,
    0x4E, 0x22, 0xF6, 0x4F, 0x29, 0x03, 0x50, 0x30, 0x10, 0x51, 0x37, 0x1D, 0x52, 0x3E, 0x2A, 0x53, 0x45, 0x37, 0x54,
    0x4C, 0x44, 0x55, 0x53, 0x51, 0x56, 0x5A, 0x5E, 0x57, 0x61, 0x6B, 0x58, 0x68, 0x78, 0x59, 0x6F, 0x85, 0x5A, 0x76,
    0x92, 0x5B, 0x7D, 0x9F, 0x5C, 0x84, 0xAC, 0x5D, 0x8B, 0xB9, 0x5E, 0x92, 0xC6, 0x5F, 0x99, 0xD3, 0x60, 0xA0, 0xE0,
    0x61, 0xA7, 0xED, 0x62, 0xAE, 0xFA, 0x63, 0xB5, 0x07, 0x64, 0xBC, 0x14, 0x65, 0xC3, 0x21, 0x66, 0xCA, 0x2E, 0x67,
    0xD1, 0x3B, 0x68, 0xD8, 0x48, 0x69, 0xDF, 0x55, 0x6A, 0xE6, 0x62, 0x6B, 0xED, 0x6F, 0x6C, 0xF4, 0x7C, 0x6D, 0xFB,
    0x89, 0x6E, 0x02, 0x96, 0x6F, 0x09, 0xA3, 0x70, 0x10, 0xB0, 0x71, 0x17, 0xBD, 0x72, 0x1E, 0xCA, 0x73, 0x25, 0xD7,
    0x74, 0x2C, 0xE4, 0x75, 0x33, 0xF1, 0x76, 0x3A, 0xFE, 0x77, 0x41, 0x0B, 0x78, 0x48, 0x18, 0x79, 0x4F, 0x25, 0x7A,
    0x56, 0x32, 0x7B, 0x5D, 0x3F, 0x7C, 0x64, 0x4C, 0x7D, 0x6B, 0x59, 0x7E, 0x72, 0x66, 0x7F, 0x79, 0x73, 0x80, 0x80,
    0x80, 0x81, 0x87, 0x8D, 0x82, 0x8E, 0x9A, 0x83, 0x95, 0xA7, 0x84, 0x9C, 0xB4, 0x85, 0xA3, 0xC1, 0x86, 0xAA, 0xCE,
    0x87, 0xB1, 0xDB, 0x88, 0xB8, 0xE8, 0x89, 0xBF, 0xF5, 0x8A, 0xC6, 0x02, 0x8B, 0xCD, 0x0F, 0x8C, 0xD4, 0x1C, 0x8D,
    0xDB, 0x29, 0x8E, 0xE2, 0x36, 0x8F, 0xE9, 0x43, 0x90, 0xF0, 0x50, 0x91, 0xF7, 0x5D, 0x92, 0xFE, 0x6A, 0x93, 0x05,
    0x77, 0x94, 0x0C, 0x84, 0x95, 0x13, 0x91, 0x96, 0x1A, 0x9E, 0x97, 0x21, 0xAB, 0x98, 0x28, 0xB8, 0x99, 0x2F, 0xC5,
    0x9A, 0x36, 0xD2, 0x9B, 0x3D, 0xDF, 0x9C, 0x44, 0xEC, 0x9D, 0x4B, 0xF9, 0x9E, 0x52, 0x06, 0x9F, 0x59, 0x13, 0xA0,
    0x60, 0x20, 0xA1, 0x67, 0x2D, 0xA2, 0x6E, 0x3A, 0xA3, 0x75, 0x47, 0xA4, 0x7C, 0x54, 0xA5, 0x83, 0x61, 0xA6, 0x8A,
    0x6E, 0xA7, 0x91, 0x7B, 0xA8, 0x98, 0x88, 0xA9, 0x9F, 0x95, 0xAA, 0xA6, 0xA2, 0xAB, 0xAD, 0xAF, 0xAC, 0xB4, 0xBC,
    0xAD, 0xBB, 0xC9, 0xAE, 0xC2, 0xD6, 0xAF, 0xC9, 0xE3, 0xB0, 0xD0, 0xF0, 0xB1, 0xD7, 0xFD, 0xB2, 0xDE, 0x0A, 0xB3,
    0xE5, 0x17, 0xB4, 0xEC, 0x24, 0xB5, 0xF3, 0x31, 0xB6, 0xFA, 0x3E, 0xB7, 0x01, 0x4B, 0xB8, 0x08, 0x58, 0xB9, 0x0F,
    0x65, 0xBA, 0x16, 0x72, 0xBB, 0x1D, 0x7F, 0xBC, 0x24, 0x8C, 0xBD, 0x2B, 0x99, 0xBE, 0x32, 0xA6, 0xBF, 0x39, 0xB3,
    0xC0, 0x40, 0xC0, 0xC1, 0x47, 0xCD, 0xC2, 0x4E, 0xDA, 0xC3, 0x55, 0xE7, 0xC4, 0x5C, 0xF4, 0xC5, 0x63, 0x01, 0xC6,
    0x6A, 0x0E, 0xC7, 0x71, 0x1B, 0xC8, 0x78, 0x28, 0xC9, 0x7F, 0x35, 0xCA, 0x86, 0x42, 0xCB, 0x8D, 0x4F, 0xCC, 0x94,
    0x5C, 0xCD, 0x9B, 0x69, 0xCE, 0xA2, 0x76, 0xCF, 0xA9, 0x83, 0xD0, 0xB0, 0x90, 0xD1, 0xB7, 0x9D, 0xD2, 0xBE, 0xAA,
    0xD3, 0xC5, 0xB7, 0xD4, 0xCC, 0xC4, 0xD5, 0xD3, 0xD1, 0xD6, 0xDA, 0xDE, 0xD7, 0xE1, 0xEB, 0xD8, 0xE8, 0xF8, 0xD9,
    0xEF, 0x05, 0xDA, 0xF6, 0x12, 0xDB, 0xFD, 0x1F, 0xDC, 0x04, 0x2C, 0xDD, 0x0B, 0x39, 0xDE, 0x12, 0x46, 0xDF, 0x19,
    0x53, 0xE0, 0x20, 0x60, 0xE1, 0x27, 0x6D, 0xE2, 0x2E, 0x7A, 0xE3, 0x35, 0x87, 0xE4, 0x3C, 0x94, 0xE5, 0x43, 0xA1,
    0xE6, 0x4A, 0xAE, 0xE7, 0x51, 0xBB, 0xE8, 0x58, 0xC8, 0xE9, 0x5F, 0xD5, 0xEA, 0x66, 0xE2, 0xEB, 0x6D, 0xEF, 0xEC,
    0x74, 0xFC, 0xED, 0x7B, 0x09, 0xEE, 0x82, 0x16, 0xEF, 0x89, 0x23, 0xF0, 0x90, 0x30, 0xF1, 0x97, 0x3D, 0xF2, 0x9E,
    0x4A, 0xF3, 0xA5, 0x57, 0xF4, 0xAC, 0x64, 0xF5, 0xB3, 0x71, 0xF6, 0xBA, 0x7E, 0xF7, 0xC1, 0x8B, 0xF8, 0xC8, 0x98,
    0xF9, 0xCF, 0xA5, 0xFA, 0xD6, 0xB2, 0xFB, 0xDD, 0xBF, 0xFC, 0xE4, 0xCC, 0xFD, 0xEB, 0xD9, 0xFE, 0xF2, 0xE6, 0xFF,
    0xF9, 0xF3, 0x2C, 0x00, 0x00, 0x00, 0x00, 0x25, 0x00, 0x1D, 0x00, 0x40, 0x08, 0xFF, 0x00, 0x01, 0x0C, 0x30, 0x90,
    0x80, 0xC1, 0x03, 0x09, 0x15, 0x30, 0x6C, 0xF0, 0x10, 0x82, 0xC4, 0x09, 0x15, 0x2D, 0x60, 0xCC, 0xB0, 0x91, 0x83,
    0xC7, 0x0F, 0x21, 0x45, 0x90, 0x2C, 0x71, 0x12, 0x85, 0xCA, 0x15, 0x2D, 0x5D, 0xC0, 0x8C, 0x31, 0x93, 0x86, 0x0D,
    0x8A, 0x15, 0x2E, 0x62, 0xD0, 0xB8, 0xA1, 0xA3, 0x07, 0x90, 0x21, 0x46, 0x92, 0x30, 0x79, 0x22, 0xA5, 0x0A, 0x96,
    0x2D, 0x5E, 0xC2, 0x90, 0x39, 0xA3, 0xA6, 0x0D, 0x9C, 0x39, 0x76, 0xF2, 0xF0, 0xF9, 0x23, 0xA8, 0x10, 0xA2, 0x45,
    0x8E, 0x22, 0x51, 0x82, 0x32, 0xC5, 0x4A, 0x16, 0x2E, 0x5F, 0xC4, 0x94, 0x41, 0xB3, 0xC6, 0x4D, 0x1C, 0x3A, 0x77,
    0xF4, 0xF4, 0x01, 0x34, 0xC8, 0x50, 0x22, 0x46, 0x8F, 0x24, 0x55, 0xC2, 0xB4, 0xC9, 0x53, 0x28, 0x52, 0xA7, 0x54,
    0xB5, 0x82, 0x35, 0xCB, 0x56, 0x2E, 0x5E, 0x78, 0xF6, 0xF8, 0x09, 0x44, 0xE8, 0x90, 0xA2, 0x46, 0x90, 0x26, 0x59,
    0xCA, 0xC4, 0xE9, 0x93, 0xA8, 0x52, 0xA8, 0x56, 0xB9, 0x8A, 0x45, 0xEB, 0x96, 0xAE, 0x5E, 0xC0, 0x86, 0x19, 0x0B,
    0x40, 0xE0, 0x80, 0x82, 0x06, 0x10, 0x26, 0x58, 0xC8, 0xC0, 0x81, 0xC2, 0x05, 0x0D, 0x1D, 0x40, 0x8C, 0x30, 0x91,
    0x82, 0xC5, 0x0B, 0x19, 0x35, 0x70, 0xEC, 0xF0, 0x11, 0x84, 0xC8, 0x11, 0x25, 0x4D, 0x98, 0x3A, 0x85, 0x2A, 0x95,
    0xAA, 0x55, 0xAC, 0x5A, 0x01, 0x59, 0xC4, 0xA8, 0x91, 0xA3, 0x47, 0x90, 0x22, 0x49, 0xB2, 0x79, 0x23, 0xA7, 0x4E,
    0xDC, 0xB9, 0x75, 0xEF, 0xE6, 0xDD, 0xDB, 0xF7, 0x2F, 0xAA, 0x9D, 0x3D, 0x7F, 0x06, 0x1D, 0x5A, 0xF4, 0x68, 0x52,
    0x4A, 0x97, 0x34, 0x75, 0x02, 0x35, 0xCA, 0x54, 0x2A, 0x56, 0xAF, 0x64, 0xD5, 0xC2, 0xB5, 0xCB, 0x57, 0x30, 0x62,
    0xC7, 0x04, 0x14, 0xFF, 0x40, 0x00, 0x56, 0x2C, 0x59, 0xB3, 0x68, 0xD5, 0xB2, 0x75, 0xCB, 0xEB, 0x97, 0xB0, 0x62,
    0x02, 0x09, 0x1A, 0x44, 0xA8, 0x90, 0xA1, 0x43, 0x88, 0x30, 0x1E, 0x47, 0x9E, 0xCC, 0xE1, 0x83, 0x88, 0x12, 0x27,
    0xA5, 0xB4, 0x52, 0x4B, 0x2F, 0xC5, 0x34, 0x53, 0x4D, 0x37, 0xE5, 0x84, 0x9C, 0x4F, 0x40, 0xD9, 0xF7, 0x50, 0x44,
    0x13, 0x55, 0x74, 0x51, 0x46, 0x1B, 0x75, 0xF4, 0x51, 0x48, 0x23, 0x95, 0xC4, 0x9B, 0x6F, 0x72, 0xD1, 0x65, 0x17,
    0x68, 0xA2, 0x91, 0x66, 0x1A, 0x6A, 0xAA, 0x3D, 0x15, 0xD5, 0x54, 0x55, 0x5D, 0x95, 0xD5, 0x56, 0x5D, 0x7D, 0x15,
    0xD6, 0x58, 0x65, 0x19, 0x48, 0x93, 0x4D, 0x38, 0xE9, 0xC4, 0x13, 0x83, 0xCB, 0x11, 0x65, 0x14, 0x52, 0x4A, 0x45,
    0x37, 0x5D, 0x75, 0xD7, 0x65, 0x87, 0x5B, 0x86, 0xBB, 0xF5, 0xF6, 0x9B, 0x87, 0xC2, 0xE9, 0xC5, 0x97, 0x5F, 0x80,
    0x09, 0x46, 0x98, 0x61, 0x88, 0x29, 0xF6, 0xDA, 0x8A, 0x5C, 0x79, 0x55, 0x1E, 0x8C, 0xE8, 0xA5, 0xB5, 0x56, 0x5B,
    0x6F, 0xB9, 0x07, 0xDF, 0x40, 0x05, 0x1D, 0xD4, 0x1C, 0x8F, 0xD0, 0x49, 0x47, 0x9D, 0x75, 0xD8, 0x69, 0xC7, 0x9D,
    0x77, 0xE0, 0x89, 0x87, 0xC0, 0x02, 0x0E, 0x44, 0x60, 0x19, 0x66, 0x9A, 0x99, 0x30, 0x1E, 0x9C, 0x72, 0x5E, 0x96,
    0xD9, 0x66, 0x9D, 0x7D, 0x16, 0xDA, 0x68, 0xA5, 0x9D, 0x96, 0x5A, 0x53, 0x26, 0xB6, 0x96, 0xE2, 0x41, 0x09, 0x2D,
    0xD4, 0xD0, 0x83, 0x12, 0x51, 0x34, 0x1B, 0x85, 0xB6, 0x5D, 0x98, 0x9B, 0x86, 0x46, 0xEE, 0x41, 0x99, 0x7F, 0x00,
    0xA2, 0xA4, 0x12, 0x4B, 0x2E, 0xC1, 0x24, 0xD3, 0x8C, 0x09, 0xDA, 0x98, 0x1C, 0x50, 0x42, 0xE9, 0xC8, 0xA7, 0x67,
    0x20, 0x02, 0x3A, 0xE2, 0xA0, 0xAB, 0x9D, 0xE8, 0x9A, 0x8A, 0xB1, 0xB5, 0xA1, 0x08, 0x16, 0x84, 0x8E, 0x4E, 0x58,
    0x9B, 0x85, 0x43, 0xEA, 0xB6, 0xE1, 0x91, 0xC1, 0xE1, 0xA5, 0x24, 0xA7, 0x05, 0x7E, 0x8A, 0x60, 0x8D, 0x0B, 0x2A,
    0x57, 0xEA, 0x98, 0xCF, 0xF9, 0x48, 0x5D, 0xA0, 0x24, 0x12, 0xCA, 0x1A, 0x8A, 0x53, 0xC6, 0x6A, 0xE5, 0x8B, 0xE7,
    0x9D, 0xA5, 0x65, 0x85, 0xB7, 0x61, 0xA8, 0x6B, 0xA5, 0xC0, 0xD9, 0xE5, 0x2B, 0x71, 0x4C, 0x06, 0x36, 0x58, 0x61,
    0x34, 0x2A, 0x78, 0xA3, 0xB1, 0xCC, 0xED, 0x98, 0xAC, 0x99, 0x40, 0xA6, 0xB9, 0x5D, 0x77, 0xC1, 0xB8, 0x9A, 0x22,
    0x6C, 0x2C, 0x4E, 0x6B, 0x5E, 0x59, 0xD6, 0xAA, 0xC7, 0x65, 0x7B, 0xEF, 0x09, 0x44, 0x29, 0x87, 0xDD, 0x26, 0x09,
    0xAE, 0x71, 0x4E, 0x16, 0x76, 0x58, 0x62, 0x8B, 0x35, 0xF6, 0x18, 0xA9, 0xE9, 0x3A, 0xD7, 0x23, 0xBB, 0x68, 0x66,
    0xF7, 0x2E, 0x9B, 0xE1, 0xDD, 0x19, 0xA7, 0x65, 0xF5, 0xBA, 0x78, 0x6F, 0x96, 0xFA, 0xB2, 0xE7, 0x65, 0x7C, 0x61,
    0xD2, 0xA7, 0xA8, 0xB7, 0xC3, 0x2D, 0x49, 0xF0, 0xB8, 0x50, 0x22, 0xCC, 0x98, 0x63, 0x90, 0x49, 0x76, 0xE9, 0x7F,
    0x27, 0x05, 0x04, 0x00, 0x3B,
};

TEST_CASE("GIF decoder matches an independently encoded interlaced GIF") {
  Catcher catcher;
  const std::vector<uint8_t> gif(kPillowInterlaced37x29, kPillowInterlaced37x29 + sizeof(kPillowInterlaced37x29));
  REQUIRE(decodeTo(gif, catcher) == gifraster::Status::Ok);
  REQUIRE(catcher.rows.size() == 29);
  std::vector<uint8_t> flat;
  for (const auto& r : catcher.rows) {
    REQUIRE(r.size() == 37);
    flat.insert(flat.end(), r.begin(), r.end());
  }
  CHECK(gifCrc32(flat) == 0xA2D91678u);  // CRC-32 of the 1073 expected gray values
}

#endif
